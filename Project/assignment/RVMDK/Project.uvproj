# Keil uVision project Project.uvproj, settings and files
target ET-STM32F-ARM-KIT (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: CE51-Com-Interface-Assignment +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM32F_ARM_KIT
  c include: ..\;..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities;..\..\..\Libraries\STM32_ETH_Driver\src;..\..\..\Libraries\STM32_ETH_Driver\inc;..\..\..\Libraries\STM32_USB-FS-Device_Driver\src;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../: main.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h main.h
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_flash.c
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
  group ET_STM32_BOARD
    ../../../Utilities/: et_stm32f_arm_kit.c et_stm32f_arm_kit_i2c.c et_stm32f_arm_kit_lcd.c et_stm32f_arm_kit_uart.c et_stm32f_arm_kit.h et_stm32f_arm_kit_i2c.h et_stm32f_arm_kit_lcd.h et_stm32f_arm_kit_uart.h
    ../../../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group RVMDK
    ../../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_md.s startup_stm32f10x_ld.s
  group Doc
    ./: readme.txt
